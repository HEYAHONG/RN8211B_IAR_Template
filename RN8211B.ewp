# IAR project RN8211B.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: lib\CMSIS\CM0\CoreSupport; lib\CMSIS\CM0\DeviceSupport\Renergy\RN8211B; FreeRTOS\FreeRTOS-Port; FreeRTOS\FreeRTOS-Kernel\include; FreeRTOS\FreeRTOS-Kernel\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AUserIncludes: FreeRTOS\FreeRTOS-Port
  OBJCOPY.OOCOutputFile: RN8211B.srec
  ILINK.IlinkOutputFile: RN8211B.out
  ILINK.IlinkIcfFile: D:\RN8211B_Project\RN8211B\device\RN8211B.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: $PROJ_DIR$; lib\CMSIS\CM0\CoreSupport; lib\CMSIS\CM0\DeviceSupport\Renergy\RN8211B\startup\iar; lib\CMSIS\CM0\DeviceSupport\Renergy\RN8211B; FreeRTOS\FreeRTOS-Port; FreeRTOS\FreeRTOS-Kernel\include; FreeRTOS\FreeRTOS-Kernel\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group CMSIS/CoreSupport
    lib/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h core_cmFunc.h core_cmInstr.h
  group CMSIS/System
    lib/CMSIS/CM0/DeviceSupport/Renergy/RN8211B/: RN8211B.h system_RN8211B.c system_RN8211B.h
  group CMSIS/System/startup
    lib/CMSIS/CM0/DeviceSupport/Renergy/RN8211B/startup/iar/: startup_RN8211B.s
  group FreeRTOS/Kernel
    FreeRTOS/FreeRTOS-Kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Kernel/CoreCM0
    FreeRTOS/FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group FreeRTOS/Kernel/MemMang
    FreeRTOS/FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group FreeRTOS/Port
    FreeRTOS/FreeRTOS-Port/: freertos.c FreeRTOSConfig.h
  group main
    ./: main.c
